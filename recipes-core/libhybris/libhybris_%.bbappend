# we have android-headers-athene
COMPATIBLE_MACHINE_cedric = "(^cedric$)"
