FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_athene = "^athene$"
COMPATIBLE_MACHINE_cedric = "^cedric$"
